/* SPDX-License-Identifier: Apache-2.0 */
#include "local_sha_hw.h"
#ifdef __NuttX__
#include "espressif/esp_sha.h"
#else
#include "esp_sha.h"
#endif
#include <errno.h>
#include <pthread.h>
#include <string.h>

/* Existing NuttX driver serializes each update and saves/restores each context.
 * Never hold a SHA lock during SD reads or reset an already initialized engine.
 * No model data is resident while idle. */
static pthread_once_t init_once=PTHREAD_ONCE_INIT;
static int init_result=-ENODEV;
static void initialize(void)
{init_result=esp_sha_init();if(init_result==-EBUSY)init_result=0;}

static int selftest(struct glv_memory *memory)
{
  static const unsigned lengths[]={0,3,55,56,63,64,65,127,128,129};
  static const unsigned char expected[][32]={
    {0xe3,0xb0,0xc4,0x42,0x98,0xfc,0x1c,0x14,0x9a,0xfb,0xf4,0xc8,0x99,0x6f,0xb9,0x24,0x27,0xae,0x41,0xe4,0x64,0x9b,0x93,0x4c,0xa4,0x95,0x99,0x1b,0x78,0x52,0xb8,0x55},
    {0xae,0x4b,0x32,0x80,0xe5,0x6e,0x2f,0xaf,0x83,0xf4,0x14,0xa6,0xe3,0xda,0xbe,0x9d,0x5f,0xbe,0x18,0x97,0x65,0x44,0xc0,0x5f,0xed,0x12,0x1a,0xcc,0xb8,0x5b,0x53,0xfc},
    {0x46,0x3e,0xb2,0x8e,0x72,0xf8,0x2e,0x0a,0x96,0xc0,0xa4,0xcc,0x53,0x69,0x0c,0x57,0x12,0x81,0x13,0x1f,0x67,0x2a,0xa2,0x29,0xe0,0xd4,0x5a,0xe5,0x9b,0x59,0x8b,0x59},
    {0xda,0x2a,0xe4,0xd6,0xb3,0x67,0x48,0xf2,0xa3,0x18,0xf2,0x3e,0x7a,0xb1,0xdf,0xdf,0x45,0xac,0xdc,0x9d,0x04,0x9b,0xd8,0x0e,0x59,0xde,0x82,0xa6,0x08,0x95,0xf5,0x62},
    {0x29,0xaf,0x26,0x86,0xfd,0x53,0x37,0x4a,0x36,0xb0,0x84,0x66,0x94,0xcc,0x34,0x21,0x77,0xe4,0x28,0xd1,0x64,0x75,0x15,0xf0,0x78,0x78,0x4d,0x69,0xcd,0xb9,0xe4,0x88},
    {0xfd,0xea,0xb9,0xac,0xf3,0x71,0x03,0x62,0xbd,0x26,0x58,0xcd,0xc9,0xa2,0x9e,0x8f,0x9c,0x75,0x7f,0xcf,0x98,0x11,0x60,0x3a,0x8c,0x44,0x7c,0xd1,0xd9,0x15,0x11,0x08},
    {0x4b,0xfd,0x2c,0x8b,0x6f,0x1e,0xec,0x7a,0x2a,0xfe,0xb4,0x8b,0x93,0x4e,0xe4,0xb2,0x69,0x41,0x82,0x02,0x7e,0x6d,0x0f,0xc0,0x75,0x07,0x4f,0x2f,0xab,0xb3,0x17,0x81},
    {0x92,0xca,0x0f,0xa6,0x65,0x1e,0xe2,0xf9,0x7b,0x88,0x4b,0x72,0x46,0xa5,0x62,0xfa,0x71,0x25,0x0f,0xed,0xef,0xe5,0xeb,0xf2,0x70,0xd3,0x1c,0x54,0x6b,0xfe,0xa9,0x76},
    {0x47,0x1f,0xb9,0x43,0xaa,0x23,0xc5,0x11,0xf6,0xf7,0x2f,0x8d,0x16,0x52,0xd9,0xc8,0x80,0xcf,0xa3,0x92,0xad,0x80,0x50,0x31,0x20,0x54,0x77,0x03,0xe5,0x6a,0x2b,0xe5},
    {0x50,0x99,0xc6,0xa5,0x62,0x03,0xf9,0x68,0x7f,0x7d,0x33,0xf4,0xbf,0xdf,0x57,0x6d,0x31,0xdc,0x91,0xf6,0xb6,0x95,0xec,0xea,0x38,0xb2,0x77,0x0c,0x87,0x63,0x11,0x35},
  };
  _Alignas(4) unsigned char pattern[129];
  for(unsigned i=0;i<sizeof(pattern);i++)pattern[i]=(unsigned char)i;
  for(unsigned test=0;test<sizeof(lengths)/sizeof(lengths[0]);test++){
    struct esp_sha256_context_s a,b;unsigned char da[32],db[32];
    esp_sha256_init(&a);esp_sha256_init(&b);
    int ret=esp_sha256_starts(&a,false);if(!ret)ret=esp_sha256_starts(&b,false);
    unsigned pa=0,pb=0,n=lengths[test];
    while(!ret&&(pa<n||pb<n)){
      if((ret=glv_cancel(memory)))break;
      if(pa<n){unsigned size=n-pa;if(size>64)size=64;ret=esp_sha256_update(&a,pattern+pa,size);pa+=size;}
      if(!ret&&pb<n){unsigned size=n-pb;if(size>3)size=3;ret=esp_sha256_update(&b,pattern+pb,size);pb+=size;}
    }
    if(!ret)ret=esp_sha256_finish(&a,da);
    if(!ret)ret=esp_sha256_finish(&b,db);
    if(!ret&&(memcmp(da,expected[test],32)||memcmp(db,expected[test],32)))ret=-EILSEQ;
    memset(&a,0,sizeof(a));memset(&b,0,sizeof(b));
    if(ret)return ret;
  }
  memory->profile.sha_hw_selftests++;return 0;
}

int glv_sha_hw_file(FILE *file,size_t expected,unsigned char digest[32],struct glv_memory *memory)
{
  int ret=glv_cancel(memory);if(ret)return ret;
  ret=pthread_once(&init_once,initialize);if(ret)return -ret;if(init_result)return init_result;
  memory->profile.sha_hw_backend=1;
  if(!memory->profile.sha_hw_selftests){
    uint64_t began=glv_now_us();ret=selftest(memory);memory->profile.sha_compute_us+=glv_now_us()-began;
    if(ret)return ret;
  }
  struct esp_sha256_context_s context;esp_sha256_init(&context);
  ret=esp_sha256_starts(&context,false);
  _Alignas(4) unsigned char data[4096],result[32];
  for(size_t bytes=0;!ret&&bytes<expected;){
    if((ret=glv_cancel(memory)))break;
    size_t size=expected-bytes;if(size>sizeof(data))size=sizeof(data);
    uint64_t began=glv_now_us();size_t got=fread(data,1,size,file);
    memory->profile.sha_read_us+=glv_now_us()-began;memory->profile.sha_bytes+=got;
    if(got!=size){ret=-EIO;break;}
    if((ret=glv_cancel(memory)))break;
    began=glv_now_us();ret=esp_sha256_update(&context,data,got);
    memory->profile.sha_compute_us+=glv_now_us()-began;
    if(!ret){memory->profile.sha_hw_updates++;bytes+=got;}
  }
  if(!ret)ret=glv_cancel(memory);
  if(!ret){uint64_t began=glv_now_us();ret=esp_sha256_finish(&context,result);memory->profile.sha_compute_us+=glv_now_us()-began;}
  if(!ret)ret=glv_cancel(memory);
  if(!ret){memcpy(digest,result,32);memory->profile.sha_hw_files++;}
  memset(&context,0,sizeof(context));memset(result,0,sizeof(result));return ret;
}
